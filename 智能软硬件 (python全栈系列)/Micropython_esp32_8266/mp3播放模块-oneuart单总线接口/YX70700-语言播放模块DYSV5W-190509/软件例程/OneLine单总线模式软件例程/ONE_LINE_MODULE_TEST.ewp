# IAR project ONE_LINE_MODULE_TEST.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: F:\Products\Yuyin module\program\例程\ONE_LINE_MODULE\inc; F:\Products\Yuyin module\program\例程\ONE_LINE_MODULE\src; F:\Products\Yuyin module\program\例程\ONE_LINE_MODULE\LIB\inc; F:\Products\Yuyin module\program\例程\ONE_LINE_MODULE\LIB\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: ONE_LINE_MODULE_TEST.srec
  ILINK.IlinkOutputFile: ONE_LINE_MODULE_TEST.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group INC
    inc/: clk.h delay.h IO.h LED.H main.h one_line_cmd.h stm8s.h stm8s_conf.h stm8s_it.h TIM2.h uart.h
  group SRC
    src/: clk.c delay.c IO.c LED.C main.c one_line_cmd.c stm8s_it.c TIM2.c uart.c
