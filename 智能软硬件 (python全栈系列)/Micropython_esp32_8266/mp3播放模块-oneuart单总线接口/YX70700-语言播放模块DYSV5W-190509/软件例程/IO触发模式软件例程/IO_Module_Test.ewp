# IAR project IO_Module_Test.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: F:\Products\Yuyin module\program\IO_MODULE\inc; F:\Products\Yuyin module\program\IO_MODULE\src; F:\Products\Yuyin module\program\IO_MODULE\LIB\inc; F:\Products\Yuyin module\program\IO_MODULE\LIB\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: IO_Module_Test.srec
  ILINK.IlinkOutputFile: IO_Module_Test.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group inc
    inc/: clk.h delay.h IO_mode.h LED.H main.h stm8s_conf.h stm8s_it.h TIM2.h
  group src
    src/: clk.c delay.c IO_mode.c LED.C main.c stm8s_it.c TIM2.c
